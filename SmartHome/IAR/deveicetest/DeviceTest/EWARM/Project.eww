<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\DeviceTest.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\smarthometest\EWARM\smarthometest.ewp</path>
  </project>
  <batchBuild/>
</workspace>


