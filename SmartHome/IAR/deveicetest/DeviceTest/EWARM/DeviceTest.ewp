# IAR project DeviceTest.ewp, settings and files
configuration DeviceTest Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xBA ST STM32L152xBA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L152xBA
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ..\..\..\..\Code\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DeviceTest.hex
  ILINK.IlinkOutputFile: DeviceTest Configuration.out
  ILINK.IlinkIcfFile: stm32l152xba_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/app
    ../../../../Code/rtc/: apprtc.c
    ../../../../Code/common/: common.c
    ../../../../Code/deveice/: deveice.c
    ../../../../Code/Init/: Init.c
    ../../../../Code/lcddriver/: lcddriver.c
    ../../../../Code/Uart/: uartapp.c
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l152xba.s
  group Application/inc
    ../../../../Code/inc/: apprtc.h common.h deveice.h include.h init.h lcddriver.h uartapp.h
  group Application/User
    ../Src/: gpio.c lcd.c main.c rtc.c stm32l1xx_hal_msp.c stm32l1xx_it.c usart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_lcd.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_uart.c
