# IAR project project.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: MKM34Z128xxx5 Freescale MKM34Z128xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.IExtraOptions: --no_mem_idioms
  ICCARM.CCIncludePath2: ..\..\..\..\build\iar_6_50\fraclib; ..\..\..\..\build\iar_6_50\meterlib; ..\..\..\..\src\fraclib; ..\..\..\..\src\meterlib; ..\..\..\..\src\common; ..\..\..\..\src\drivers; ..\..\..\..\src\freemaster; ..\..\..\..\src\projects\_twr_emeter_demo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: MKMxxZ128_flash_NVM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group common
    ../../../../src/common/: arch_delay.h arm_cm0.c arm_cm0.h common.h iohw.h start.c start.h startup.h system.c system.h
  group common/headers
    ../../../../src/common/headers/: MKM34Z5.h
  group drivers
    ../../../../src/drivers/: drivers.h
  group drivers/adc
    ../../../../src/drivers/adc/: adc.c adc.h
  group drivers/afe
    ../../../../src/drivers/afe/: afe.c afe.h
  group drivers/aips
    ../../../../src/drivers/aips/: aips.c aips.h
  group drivers/cmp
    ../../../../src/drivers/cmp/: cmp.c cmp.h
  group drivers/crc
    ../../../../src/drivers/crc/: crc.c crc.h
  group drivers/dma
    ../../../../src/drivers/dma/: dma.c dma.h
  group drivers/fll
    ../../../../src/drivers/fll/: fll.c fll.h
  group drivers/ftfa
    ../../../../src/drivers/ftfa/: ftfa.c ftfa.h
  group drivers/gpio
    ../../../../src/drivers/gpio/: gpio.c gpio.h
  group drivers/i2c
    ../../../../src/drivers/i2c/: i2c.c i2c.h
  group drivers/irtc
    ../../../../src/drivers/irtc/: irtc.c irtc.h
  group drivers/llwu
    ../../../../src/drivers/llwu/: llwu.c llwu.h
  group drivers/lptmr
    ../../../../src/drivers/lptmr/: lptmr.c lptmr.h
  group drivers/mcm
    ../../../../src/drivers/mcm/: mcm.c mcm.h
  group drivers/mpu
    ../../../../src/drivers/mpu/: mpu.c mpu.h
  group drivers/osc
    ../../../../src/drivers/osc/: osc.c osc.h
  group drivers/osc32k
    ../../../../src/drivers/osc32k/: osc32k.c osc32k.h
  group drivers/pit
    ../../../../src/drivers/pit/: pit.c pit.h
  group drivers/pll
    ../../../../src/drivers/pll/: pll.c pll.h
  group drivers/pmc
    ../../../../src/drivers/pmc/: pmc.c pmc.h
  group drivers/rcm
    ../../../../src/drivers/rcm/: rcm.c rcm.h
  group drivers/rnga
    ../../../../src/drivers/rnga/: rnga.c rnga.h
  group drivers/sim
    ../../../../src/drivers/sim/: sim.c sim.h
  group drivers/smc
    ../../../../src/drivers/smc/: smc.c smc.h
  group drivers/spi
    ../../../../src/drivers/spi/: spi.c spi.h
  group drivers/swisr
    ../../../../src/drivers/swisr/: swisr.c swisr.h
  group drivers/syst
    ../../../../src/drivers/syst/: syst.c syst.h
  group drivers/tmr
    ../../../../src/drivers/tmr/: tmr.c tmr.h
  group drivers/uart
    ../../../../src/drivers/uart/: uart.c uart.h
  group drivers/vref
    ../../../../src/drivers/vref/: vref.c vref.h
  group drivers/wdog
    ../../../../src/drivers/wdog/: wdog.c wdog.h
  group drivers/xbar
    ../../../../src/drivers/xbar/: xbar.c xbar.h
  group fraclib
    ../../fraclib/: fraclib.a
    ../../../../src/fraclib/: fraclib.h FRACLIB_Inlines.h FRACLIB_Mul32.h FRACLIB_Types.h
  group freemaster
    ../../../../src/freemaster/: freemaster.h freemaster_appcmd.c freemaster_can.c freemaster_Kxx.c freemaster_Kxx.h freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_serial.c freemaster_sfio.c freemaster_tsa.c freemaster_tsa.h
  group meterlib
    ../../meterlib/: meterlib.a
    ../../../../src/meterlib/: meterlib.h
  group project
    ../../../../src/projects/_twr_emeter_demo/: appconfig.h config.c config.h freemaster_cfg.h LCD.c LCD.h meterlib1ph_cfg.h mk341ph.c mk341ph.h
  group toolchain
    ../../../../src/toolchain/iar/: arch_delay.s crt0.s startup.c
  group toolchain/config
    ./: MKMxxZ128_flash_NVM.icf
